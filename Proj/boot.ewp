# IAR project boot.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: NDEBUG; chip=2530
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\App; ..\arch\CC253x\inc; ..\common\inc; ..\drivers\CC253x\inc
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group application
    ../App/: board.c main.c
  group arch
    ../arch/CC253x/src/: interrupt_stubs.s51
  group common
    ../common/src/: binFile.c crc.c image.c
  group drivers
    ../drivers/CC253x/src/: hal_clock.c hal_flash.c hal_mcu.c hal_uart.c
